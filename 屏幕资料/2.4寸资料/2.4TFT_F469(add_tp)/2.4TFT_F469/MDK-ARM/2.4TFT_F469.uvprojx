# Keil uVision project 2.4TFT_F469.uvprojx, settings and files
target 2.4TFT_F469 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 2.4TFT_F469 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F469xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USER_APP;..\GUI
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group APP
    ../USER_APP/: lce.c sys.h pic.h TP_IN.c wm8978.c
  group GUI
    ../GUI/: ui.c ui_helpers.c ui_img_520_png.c
  group New Group
    ../GUI_DEMO/: ui_font_Big_Number.c ui_font_Bold_Font.c ui_helpers.c ui_helpers.h ui_img_icn_battery_png.c ui_img_icn_bluetooth_png.c ui_img_icn_history_png.c ui_img_img_btn_bg_png.c ui_img_img_btn_off_png.c ui_img_img_btn_on_png.c ui_img_img_heart_big_png.c ui_img_img_heart_small_png.c ui_img_img_line_png.c ui_img_img_slider_png.c ui_img_img_switch_bg_png.c ui.c
software components: CMSIS:CORE 5.4.0, LVGL:lvgl:Benchmark 8.3.0-dev, LVGL:lvgl:Demo:Widgets 8.3.0-dev, LVGL:lvgl:Essential 8.3.0-dev, LVGL:lvgl:Extra Themes 8.3.0-dev, LVGL:lvgl:Porting 8.3.0-dev
